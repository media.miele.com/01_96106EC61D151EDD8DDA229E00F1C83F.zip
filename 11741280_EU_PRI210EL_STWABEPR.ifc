Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-09-13T14:50:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 13 14:50:36 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\f13ad2b0-5f87-41b9-8590-51be414afd43\9911cd90-0c7d-41af-a58f-e4c0329d3330\ifc * Database version: 5507 * Database creation date: Tue Sep 13 14:50:36 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 13 14:50:36 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 13 14:50:36 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11741280_EU_PRI210EL_STWABEPR:53210006_EU_11741280_PRI210EL_STWABEPR, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 53210006_EU_11741280_PRI210EL_STWABEPR
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 53210006_EU_11741280_PRI210EL_STWABEPR
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Eisengrau, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_Glass Black
Pset_BuildingElementProxyCommon - sets with these values: 2
